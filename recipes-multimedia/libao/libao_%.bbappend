PACKAGECONFIG:append = " alsa"
