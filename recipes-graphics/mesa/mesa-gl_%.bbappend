CFLAGS_append_armv6 = " -DMISSING_64BIT_ATOMICS"
