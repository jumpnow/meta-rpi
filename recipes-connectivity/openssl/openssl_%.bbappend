PACKAGECONFIG_append = " cryptodev-linux"
