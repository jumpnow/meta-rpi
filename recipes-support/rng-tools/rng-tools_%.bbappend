INITSCRIPT_PARAMS = "start 38 S . stop 30 0 6 1 ."
