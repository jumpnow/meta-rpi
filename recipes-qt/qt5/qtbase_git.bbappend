PACKAGECONFIG_append = " accessibility eglfs fontconfig gles2"

DEPENDS += "userland"
